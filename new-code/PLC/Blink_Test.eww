<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\BigBrother\BigBrother.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\blink_test.ewp</path>
    </project>
    <batchBuild />
</workspace>
